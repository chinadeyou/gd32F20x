# Keil uVision project gd32F20x.uvproj, settings and files
target example (ARM-ADS)
  device: GD32F207VC GigaDevice
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: 9284
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,GD32F20X_CL
  c include: .\Firmware\CMSIS\GD\GD32F20x\Include;.\Firmware\GD32F20x_standard_peripheral\Include;.\main
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ./: startup_gd32f20x_cl.s
  group CMSIS
    ./Firmware/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group Firmware
    ./Firmware/GD32F20x_standard_peripheral/Source/: gd32f20x_adc.c gd32f20x_bkp.c gd32f20x_can.c gd32f20x_cau.c gd32f20x_cau_aes.c gd32f20x_cau_des.c gd32f20x_cau_tdes.c gd32f20x_crc.c gd32f20x_dac.c gd32f20x_dbg.c gd32f20x_dci.c gd32f20x_dma.c gd32f20x_enet.c gd32f20x_exmc.c gd32f20x_exti.c gd32f20x_fmc.c gd32f20x_fwdgt.c gd32f20x_gpio.c gd32f20x_hau.c gd32f20x_hau_sha_md5.c gd32f20x_i2c.c gd32f20x_misc.c gd32f20x_pmu.c gd32f20x_rcu.c gd32f20x_rtc.c gd32f20x_sdio.c gd32f20x_spi.c gd32f20x_timer.c gd32f20x_tli.c gd32f20x_trng.c gd32f20x_usart.c gd32f20x_wwdgt.c
  group main
    ./main/: main.c systick.c gd32f20x_it.c i2c0.c i2c1.c i2c2.c i2c0-slave.c i2c1-slave.c i2c2-slave.c adc.c ct75mmr.c ltc4280.c gt24c256.c seeprom.c
  group readme
    ./: README.txt
